# Keil uVision project GD32F527I_EVAL.uvprojx, settings and files
target GD32F527I_EVAL (6210000::V6.21::ARMCLANG)
  device: GD32F527IS GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.2.1
  cpu: IRAM(0x20000000,0x080000) IROM(0x08000000,0x780000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F527
  c include: ..\;..\..\..\Utilities;..\..\..\..\GD32F5xx_Firmware_Library\GD32F5xx_standard_peripheral\Include;..\..\..\..\GD32F5xx_Firmware_Library\CMSIS\GD\GD32F5xx\Include;..\..\..\..\GD32F5xx_Firmware_Library\CMSIS;..\Soft_Drive;..\..\25_DCI_OV2640;..\MDK-ARM;..\NET\CJSON;..\NET\ESP01S;..\NET\onenet;..\NET
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x780000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application
    ../: main.c systick.c gd32f5xx_it.c RC522.c RC522.h SG90.c UART.c
    ./: TFTLCD.c TFTLCD.h LED.h LED.c
  group CMSIS
    ../../../../GD32F5xx_Firmware_Library/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
  group GD32F5xx_Peripherals
    ../../../../GD32F5xx_Firmware_Library/GD32F5xx_standard_peripheral/Source/: gd32f5xx_adc.c gd32f5xx_can.c gd32f5xx_cau.c gd32f5xx_cau_aes.c gd32f5xx_cau_des.c gd32f5xx_cau_tdes.c gd32f5xx_crc.c gd32f5xx_ctc.c gd32f5xx_dac.c gd32f5xx_dbg.c gd32f5xx_dci.c gd32f5xx_dma.c gd32f5xx_enet.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_fwdgt.c gd32f5xx_gpio.c gd32f5xx_hau.c gd32f5xx_hau_sha_md5.c gd32f5xx_i2c.c gd32f5xx_i2c_add.c gd32f5xx_ipa.c gd32f5xx_iref.c gd32f5xx_misc.c gd32f5xx_pkcau.c gd32f5xx_pmu.c gd32f5xx_rcu.c gd32f5xx_rtc.c gd32f5xx_sai.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_tli.c gd32f5xx_trng.c gd32f5xx_usart.c gd32f5xx_wwdgt.c
  group GD32F5xx_EVAL
    ../../../Utilities/: gd32f527i_eval.c
  group Soft_Drive
    ../Soft_Drive/: dci_ov2640.c exmc_sdram.c picture.c sccb.c
  group Startup
    ../../../../GD32F5xx_Firmware_Library/CMSIS/GD/GD32F5xx/Source/ARM/: startup_gd32f5xx.s
  group Doc
    ../: readme.txt
  group NET
    ../NET/CJSON/: cJSON.c cJSON.h
    ../NET/ESP01S/: esp8266.h esp8266.c
    ../NET/MQTT/: Common.h MqttKit.c MqttKit.h
    ../NET/onenet/: base64.c base64.h hmac_sha1.c hmac_sha1.h onenet.c onenet.h
software components: CMSIS:CORE 5.2.0
