# IAR project GD32F527I_EVAL.ewp, settings and files
configuration GD32F527 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F527xS GD GD32F527xS
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32F527
  ICCARM.CCIncludePath2: ..; ..\..\..\..\GD32F5xx_Firmware_Library\GD32F5xx_standard_peripheral\Include; ..\..\..\..\GD32F5xx_Firmware_Library\CMSIS\GD\GD32F5xx\Include; ..\..\..\..\GD32F5xx_Firmware_Library\CMSIS\GD; ..\..\..\Utilities; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32F527I_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f5xx_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F5xx_Firmware_Library/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
  group Doc
    ../: readme.txt
  group GD32F5xx_EVAL
    ../../../Utilities/: gd32f527i_eval.c
  group GD32F5xx_Peripherals
    ../../../../GD32F5xx_Firmware_Library/GD32F5xx_standard_peripheral/Source/: gd32f5xx_adc.c gd32f5xx_can.c gd32f5xx_cau.c gd32f5xx_cau_aes.c gd32f5xx_cau_des.c gd32f5xx_cau_tdes.c gd32f5xx_crc.c gd32f5xx_ctc.c gd32f5xx_dac.c gd32f5xx_dbg.c gd32f5xx_dci.c gd32f5xx_dma.c gd32f5xx_enet.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_fwdgt.c gd32f5xx_gpio.c gd32f5xx_hau.c gd32f5xx_hau_sha_md5.c gd32f5xx_i2c.c gd32f5xx_i2c_add.c gd32f5xx_ipa.c gd32f5xx_iref.c gd32f5xx_misc.c gd32f5xx_pkcau.c gd32f5xx_pmu.c gd32f5xx_rcu.c gd32f5xx_rtc.c gd32f5xx_sai.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_tli.c gd32f5xx_trng.c gd32f5xx_usart.c gd32f5xx_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: dci_ov2640.c exmc_sdram.c picture.c sccb.c
  group Startup
    ../../../../GD32F5xx_Firmware_Library/CMSIS/GD/GD32F5xx/Source/IAR/: startup_gd32f5xx.s
